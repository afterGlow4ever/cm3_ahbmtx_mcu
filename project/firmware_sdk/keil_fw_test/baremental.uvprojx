# Keil uVision project baremental.uvprojx, settings and files
target fw_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: baremental +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c --output=Objects\baremental.dis Objects\baremental.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL_SDK, COMMON_DRIVER, UART_DRIVER, UART_EX_DRIVER, GPIO_DRIVER, BASTIM_DRIVER, ETH_DRIVER, ETH_TEST
  c include: ..\..\..\library\cmsis\Device\ARM\CM3DS\Include;..\..\..\library\cmsis\CMSIS\Include;..\..\..\library\drivers;..\..\..\library\drivers\common\inc;..\..\..\library\drivers\uart\inc;..\..\..\library\drivers\gpio\inc;..\..\..\library\drivers\bastim\inc;..\..\..\library\drivers\eth\inc;..\..\..\user\firmware\fw_test;..\..\..\user\firmware\fw_test\uart_bsp;..\..\..\user\firmware\fw_test\gpio_bsp;..\..\..\user\firmware\fw_test\bastim_bsp;..\..\..\user\firmware\fw_test\eth_bsp
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000 size 0x2000
  group driver
    ../../../library/drivers/common/src/: drv_common.c
    ../../../library/drivers/uart/src/: drv_uart.c drv_uart_ex.c
    ../../../library/drivers/gpio/src/: drv_gpio.c
    ../../../library/drivers/bastim/src/: drv_bastim.c
    ../../../library/drivers/eth/src/: drv_eth.c
  group startup
    ../../../library/cmsis/Device/ARM/CM3DS/Source/ARM/: startup_CM3DS.s
  group user
    ../../../user/firmware/fw_test/: interrupt.c main.c
  group hardware
    ../../../user/firmware/fw_test/uart_bsp/: uart_bsp.c uart_test.c
    ../../../user/firmware/fw_test/gpio_bsp/: gpio_bsp.c gpio_test.c
    ../../../user/firmware/fw_test/bastim_bsp/: bastim_bsp.c bastim_test.c
    ../../../user/firmware/fw_test/eth_bsp/: eth_bsp.c eth_test.c
